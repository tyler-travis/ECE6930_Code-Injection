# Keil uVision project Echo_Project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Echo_Project
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RA1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.2.111;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: echo.c uartstdio.c driverlib.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
